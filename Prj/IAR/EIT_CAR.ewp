# IAR project EIT_CAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK61FN1M0xxx15 Freescale MK61FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM4; MK60F15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFS; ..\..\Lib\USB; ..\..\EITLib\Inc; ..\..\Control\Inc; ..\..\ControlLib\Inc; ..\..\Graphic; ..\..\Platform\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EIT_CAR.hex
  ILINK.IlinkOutputFile: EIT_CAR.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N1M.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration K60FN-DEBUG (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  group App
    ../../App/Inc/: include.h MK60_conf.h MK60_it.h PORT_cfg.h
    ../../App/: main.c MK60_conf.c MK60_it.c
  group Chip
    ../../Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group Control
    ../../Control/: EIT_PID.c EIT_SpeedL.c EIT_SpeedR.c
  group ControlLib
    ../../ControlLib/: ControlGraphTask.c ControlParam.c ControlSpeedTask.c ControlVar.c
  group EITLib
    ../../EITLib/: EIT_ADC.c EIT_Buzzer.c EIT_Key.c EIT_Log.c EIT_Model.c EIT_MotorL.c EIT_MotorR.c EIT_Show.c EIT_Steer.c
    ../../Graphic/: imCom.c
  group Graphic
    ../../Graphic/: imProc.c
  group Lib
    ../../Lib/FatFs/: diskio.c
  group Platform
    ../../Platform/: CarSystem.c CarTest.c IntHandler.c
    ../../Lib/FatFs/: ff.c
  group VCAN
    ../../Board/src/: VCAN_ASCII.c VCAN_BMP.c VCAN_camera.c vcan_img2sd.c VCAN_key.c VCAN_key_event.c VCAN_LCD.c VCAN_LCD_ILI9341.c VCAN_LCD_ST7735R.c VCAN_LED.C VCAN_OV7725_Eagle.c VCAN_SCCB.c VCAN_TSL1401.c
